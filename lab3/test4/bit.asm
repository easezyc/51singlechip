	ORG	0000H
	LJMP	START
	ORG	 0030H
START:
	MOV	R1,#1FH
	MOV	R2,#10H
	MOV	R4,#00H
LOOP:
	MOV	R3,#9H
	INC	R1
	MOV	A,R1
	CJNE	A,#030H,D
	MOV	50H,R4
	SJMP	$
D:
	MOV	A,@R1
F:
	DEC	R3
	MOV R5,A
	MOV A,R3
	JZ LOOP
	MOV A,R5
	RLC	A
	JC	G
	JMP	F
G:
	INC	R4
	JMP	F	
	END	