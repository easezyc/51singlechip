E_G	BIT	P2.7
E_R	BIT	P2.6
S_G	BIT	P2.5
S_R	BIT	P2.4
W_G	BIT	P2.3
W_R	BIT	P2.2
N_G	BIT	P2.1
N_R	BIT	P2.0
A_LAMP	EQU	P2
LEN_GR	EQU	10H
	ORG	0000H
	LJMP	START
	ORG	0300H
START:	LCALL	INIT
MLOOP:	
	CLR		E_G
	SETB	E_R
	SETB	N_G
	CLR		N_R
	MOV	R5,#LEN_GR
	LCALL	DELAY
	SETB	E_G
	CLR		E_R
	SETB	W_R
	CLR		W_G
	MOV	R5,#LEN_GR
	LCALL	DELAY
	SETB	W_G
	CLR		W_R
	SETB	S_R
	CLR		S_G
	MOV	R5,#LEN_GR
	LCALL	DELAY
	SETB	S_G
	CLR		S_R
	SETB	N_R
	CLR		N_G
	MOV	R5,#LEN_GR
	LCALL	DELAY
	SJMP	MLOOP
INIT:	MOV	A_LAMP,#0FFH
	CLR	W_R
	CLR	N_R
	CLR	S_R
	RET
DELAY:	MOV	R7,#00H
	MOV	R6,#00H
LOOP:	DJNZ	R7,LOOP
	DJNZ	R6,LOOP
	DJNZ	R5,LOOP
	RET
	END