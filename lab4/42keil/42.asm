SW1		BIT		P1.2
SW2		BIT		P1.3
SW3		BIT		P1.4
SW4		BIT		P1.5
A_LAMP	EQU		P2
C_LED	EQU		P2
THREE	EQU	15H
FIVE	EQU	25H
EW_G	EQU	01100110B
NS_G	EQU	10011001B
AL_G	EQU	01010101B
AL_R	EQU	10101010B
	ORG		0000H
	LJMP	START
	ORG		0030H
START:	JB	SW1,NEXT1
	MOV		A,#1
	LCALL	DISP
	MOV	R5,#THREE
	LCALL	DELAY
	MOV		A_LAMP,#EW_G
	SJMP	START
NEXT1:	JB	SW2,NEXT2
	MOV		A,#2
	LCALL	DISP
	MOV	R5,#THREE
	LCALL	DELAY
	MOV		A_LAMP,#NS_G
	SJMP	START
NEXT2:	JB	SW3,NEXT3
	MOV		A,#3
	LCALL	DISP
	MOV	R5,#THREE
	LCALL	DELAY
	MOV		A_LAMP,#AL_G
	SJMP	START
NEXT3:	JB	SW4,START
	MOV		A,#4
	LCALL	DISP
	MOV	R5,#FIVE
	LCALL	DELAY
	MOV		A_LAMP,#AL_R
	SJMP	START
DELAY:	MOV		R7,#00H
		MOV		R6,#00H
LOOP:	DJNZ	R7,LOOP
		DJNZ	R6,LOOP
		DJNZ	R5,LOOP
		RET
DISP:	MOV		DPTR,#WTAB
		MOVC	A,@A+DPTR
		MOV		C_LED,A
		RET
WTAB:	DB	0C0H,0F9H,0A4H,0B0H
		DB	099H,092H,082H,0F8H
		DB	080H,090H,088H,083H
		DB	0C6H,0A1H,086H,08EH
	END